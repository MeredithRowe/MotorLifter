# Keil uVision project Project.uvprojx, settings and files
target MotorLifter_STM32F411 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F411RE_STEPMOTOR +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,USE_STM32F4XX_NUCLEO,
  c misc: --C99
  c include: ..\..\Inc;..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\Drivers\BSP\STM32F4xx-Nucleo;..\..\..\Drivers\BSP\Components\l6474;..\..\..\Drivers\BSP\MotorControl;..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\..\Drivers\BSP\MotorLifter\inc;..\..\..\App\MotorLifter\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/Components/l6474
    ../../../Drivers/BSP/Components/l6474/: l6474.c
  group Drivers/BSP/MotorControl
    ../../../Drivers/BSP/MotorControl/: motorcontrol.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c stm32f4xx_nucleo_ihm01a1.c
  group Drivers/BSP/Usart
    ../../../Drivers/BSP/MotorLifter/src/: MotorLifter_BSP_usart.c
  group Drivers/CMSIS
    ../../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c
  group MDK-ARM
    ../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f411xe.s
  group User
    ../../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c clock_f4.c
  group App
    ../../../App/MotorLifter/src/: MotorLifter.c
